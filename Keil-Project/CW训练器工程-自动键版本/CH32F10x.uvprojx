# Keil uVision project CH32F10x.uvprojx, settings and files
target CH32F10x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: CH32F103C8 WCH
  pack: Keil.WCH32F1xx_DFP.1.0.2
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CW_PocketTrainer +hex
  AfterMake: fromelf --bin --output ./obj/CWPT.bin ./obj/CW_PocketTrainer.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\SRC\Startup;.\SRC\StdPeriphDriver\inc;.\SRC\CMSIS;.\SRC\Debug;.\ANO_DT;.\SRC;.\SRC\StdPeriphDriver\src;.\Hardware\LED;.\Hardware\OLED;.\Battery;.\Beep;.\Timer;.\FLASH;.\DAC;.\CW;.\oled_ui;..\CWPT_V0.23_顺序练习;.\ADC;.\KEY;.\Menu
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./: Main.c ch32f10x_it.c system_ch32f10x.c
  group startup
    ./SRC/Startup/: startup_ch32f10x.s
  group core
    ./SRC/CMSIS/: core_cm3.c
  group debug
    ./SRC/Debug/: debug.c
  group peripheral
    ./SRC/StdPeriphDriver/src/: ch32f10x_adc.c ch32f10x_bkp.c ch32f10x_can.c ch32f10x_crc.c ch32f10x_dac.c ch32f10x_dbgmcu.c ch32f10x_dma.c ch32f10x_exti.c ch32f10x_flash.c ch32f10x_gpio.c ch32f10x_i2c.c ch32f10x_iwdg.c ch32f10x_misc.c ch32f10x_pwr.c ch32f10x_rcc.c ch32f10x_rtc.c ch32f10x_spi.c ch32f10x_tim.c ch32f10x_usart.c ch32f10x_usb.c ch32f10x_usb_host.c ch32f10x_wwdg.c
  group Hardware
    ./Beep/: beep.c
    ./ADC/: BSP_adc.c
    ./KEY/: Key.c
    ./Hardware/OLED/: Oled.c
    ./Timer/: Timer.c
    ./FLASH/: flash.c
    ./DAC/: dac.c
  group function
    ./Battery/: battery.c
    ./CW/: cw.c
    ./oled_ui/: oled_ui.c
    ./Menu/: menu.c
